# Keil uVision project node.uvprojx, settings and files
target nRF52810 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.30.2
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: node +hex
  AfterMake: fromelf.exe --bin -o node.bin ./Objects/node.axf
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET NRF52 NRF52810_XXAA NRF52_PAN_74
  c include: ..\nrfx;..\nrfx\soc;..\nrfx\mdk;..\nrfx\templates\nRF52810;..\nrfx\hal;..\nrfx\templates;..\nrfx\delay;..\..\..\case;..\..\..\sample\uart;..\..\..\sample\profile;..\..\..\util\ascii;..\..\..\util\fifo;..\..\..\util\slip;..\..\..\sample\led
  asm define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52810_XXAA NRF52_PAN_74
  memory RVCT4: ROM 0x10000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x4000
  group User
    ../user/: main.c
    ../nrfx/hal/: nrf_nvmc.c
  group Device
    ../nrfx/mdk/: system_nrf52810.c arm_startup_nrf52810.s
  group case
    ../../../case/: case_api.c
  group sample/profile
    ../../../sample/profile/: node_resource_discovery.c node_profile.c node_app.c node_auth.c
  group util/ascii
    ../../../util/ascii/: util_ascii.c
  group util/fifo
    ../../../util/fifo/: fifo.c
  group util/slip
    ../../../util/slip/: slip.c
  group sample/uart
    ../../../sample/uart/: simple_uart.c node_uart.c uart_frame.c simple_uart_lp.c
  group sample/led
    ../../../sample/led/: user_led.c
software components: CMSIS:CORE 5.2.0
